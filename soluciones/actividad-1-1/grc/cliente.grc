<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Cliente</value></param>
<param><key>author</key><value>IPA 2020</value></param>
<param><key>description</key><value>Signal Demux</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Demux</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>blks2_tcp_source</key>
<param><key>id</key><value>blks2_tcp_source_0_0</value></param>
<param><key>addr</key><value>0.0.0.0</value></param>
<param><key>server</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>port</key><value>12345</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blocks_stream_to_streams</key>
<param><key>id</key><value>blocks_stream_to_streams_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_streams</key><value>3</value></param>
</block>
<block>
<key>wxgui_scopesink2</key>
<param><key>id</key><value>wxgui_scopesink2_0_0</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>num_inputs</key><value>3</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>t_scale</key><value>0</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>type</key><value>float</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>v_scale</key><value>0</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
</block>
<connection><source_block_id>blks2_tcp_source_0_0</source_block_id><sink_block_id>blocks_stream_to_streams_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_streams_0</source_block_id><sink_block_id>wxgui_scopesink2_0_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
</flow_graph>
